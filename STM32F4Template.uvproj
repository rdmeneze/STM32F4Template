# Keil uVision project STM32F4Template.uvproj, settings and files
target STM32F4Template (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4Template
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;.\inc;..\lib\STM32F4xx_DSP_StdPeriph_Lib_V1.1.0\Libraries\CMSIS\Include;..\lib\STM32F4xx_DSP_StdPeriph_Lib_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group inc
    ./inc/: defs.h stm32f4xx_conf.h processor.h timer.h
  group src
    ./src/: startup_stm32f4xx.s main.c system_stm32f4xx.c timer.c
